# Keil uVision project CRYPTO_ECC_SignatureVerification.uvprojx, settings and files
target CRYPTO_ECC_SignatureVerification (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.3
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: CRYPTO_ECC_SignatureVerification
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=1
  c include: ..\..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  link misc: --map --first='startup_M2351.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../../Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c crypto.c
    ../../../../../OV7670DriverFile/: Arduino.h CameraOV7670RegisterDefinitions.h CameraOV7670Registers.h Wire.h Adafruit_ST7735_mod.cpp Arduino.cpp CameraOV7670.cpp ExampleUart.cpp Wire.cpp CameraOV7670.h setup.h
